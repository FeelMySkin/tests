# Keil uVision project i2c.uvprojx, settings and files
target i2c (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: i2c
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: USE_FULL_LL_DRIVER,STM32F401xC
  c include: .eide\deps;Core\CMSIS\CMSIS\Core\Include;Core\Drivers\Inc;Core\Device\Include
  asm define: USE_FULL_LL_DRIVER,STM32F401xC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Sources
    Core/Device/Source/Templates/arm/: startup_stm32f411xe.s
    Core/Device/Source/Templates/: system_stm32f4xx.c
    ./: main.c soft_i2c.c
  group Drivers
    Core/Drivers/Src/: stm32f4xx_ll_gpio.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_tim.c stm32f4xx_ll_utils.c
